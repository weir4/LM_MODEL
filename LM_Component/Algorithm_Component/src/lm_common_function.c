/*******************************************************************************
 * 版权所有 (C)2025, CQG
 *
 * 文件名称： lm_common_function.h
 * 文件标识： 
 * 内容摘要： 动态空间管理
 * 其它说明： 无
 * 当前版本： v1.0.0
 * 作    者：    Qiguo_Cui                   
 * 完成日期： 2025年10月23日
 *
 *******************************************************************************/


#include "lm_common_function.h"

/*******************************************************************************
 函数名称：lm_bit_divide
 功能描述：从32位整型数据中提取指定位的值（0或1）    
 输入参数：byte_data - 待处理的32位整型数据
          bit_loc   - 要提取的位位置（0-31，0表示最低位）
 输出参数：无    
 返 回 值：成功返回指定位的值（0或1），失败返回-1
 其它说明：如果位位置超出有效范围（0-31），则返回错误码-1		   
 			   
 修改日期      版本号          修改人            修改内容
 -----------------------------------------------------------------------------
 2025/11/02     V1.00          Qiguo_Cui          创建
 *******************************************************************************/  
int lm_bit_divide(int byte_data, int bit_loc)
{
    // 检查位位置是否在有效范围内（0到31位）
    if (bit_loc < 0 || bit_loc >= (int)(sizeof(int) * 8)) {
        return -1;  // 位位置无效，返回错误码-1
    }
    
    // 将数据右移到目标位，然后与1进行与操作提取该位的值
    return (byte_data >> bit_loc) & 1;
}

/*******************************************************************************
 函数名称：lm_byte_divide_high_16
 功能描述：从32位整型数据中提取高16位数据    
 输入参数：byte_comb - 32位的组合数据，高16位和低16位分别存储不同信息
 输出参数：无    
 返 回 值：提取出的高16位数据（取值范围：0x0000-0xFFFF）
 其它说明：该函数通过右移16位并屏蔽高16位来提取数据		   
 			   
 修改日期      版本号          修改人            修改内容
 -----------------------------------------------------------------------------
 2025/11/02     V1.00          Qiguo_Cui          创建
 *******************************************************************************/  
int lm_byte_divide_high_16(int byte_comb) {
    
    // 将32位数据右移16位，使高16位移动到低16位位置
    // 然后与0xFFFF进行与操作，确保只保留低16位，清除可能的高位符号扩展
    return (byte_comb >> 16) & 0xFFFF;
}

/*******************************************************************************
 函数名称：lm_byte_divide_low_16
 功能描述：从32位整型数据中提取低16位数据    
 输入参数：byte_comb - 32位的组合数据，高16位和低16位分别存储不同信息
 输出参数：无    
 返 回 值：提取出的低16位数据（取值范围：0x0000-0xFFFF）
 其它说明：该函数直接通过位掩码操作提取低16位数据		   
 			   
 修改日期      版本号          修改人            修改内容
 -----------------------------------------------------------------------------
 2025/11/02     V1.00          Qiguo_Cui          创建
 *******************************************************************************/  
int lm_byte_divide_low_16(int byte_comb) {
   
    // 直接与0xFFFF进行与操作，提取原始数据的低16位
    // 高16位在与操作中被清零，只保留需要的低16位数据
    return byte_comb & 0xFFFF;
}

/*******************************************************************************
 函数名称：lm_byte_combine
 功能描述：将两个16位整数组合成一个32位整数    
 输入参数：low_byte  - 低16位数据（取值范围：0x0000-0xFFFF）
          high_byte - 高16位数据（取值范围：0x0000-0xFFFF）
 输出参数：无    
 返 回 值：组合后的32位整数
 其它说明：高16位数据左移16位后与低16位数据进行或操作，组合成完整32位数据		   
 			   
 修改日期      版本号          修改人            修改内容
 -----------------------------------------------------------------------------
 2025/11/02     V1.00          Qiguo_Cui          创建
 *******************************************************************************/  
int lm_byte_combine(int low_byte, int high_byte) {
    
    // 首先确保输入参数只包含有效的16位数据，清除可能的高位数据
    low_byte = low_byte & 0xFFFF;   // 屏蔽低16位以外的所有位，确保只使用有效数据
    
    high_byte = high_byte & 0xFFFF; // 屏蔽低16位以外的所有位，确保只使用有效数据
    
    // 将高16位数据左移16位，使其位于32位整数的高16位位置
    // 然后与低16位数据进行或操作，组合成完整的32位整数
    return (high_byte << 16) | low_byte;
}

/*******************************************************************************
 函数名称：lm_period_normalize
 功能描述：将浮点数归一化到指定周期范围内[0, period)    
 输入参数：value  - 待归一化的浮点数
          period - 周期长度（必须为正数）
 输出参数：无    
 返 回 值：归一化后的浮点数，范围在[0, period)内
 其它说明：通过取模运算将任意浮点数映射到指定周期范围内		   
 			   
 修改日期      版本号          修改人            修改内容
 -----------------------------------------------------------------------------
 2025/11/02     V1.00          Qiguo_Cui          创建
 *******************************************************************************/  
double lm_period_normalize(double value, double period) {
    
    // 检查周期参数是否有效，周期必须为正数
    if (period <= 0.0) {
        // 如果周期无效，返回0并可通过错误处理机制通知调用者
        return 0.0;
    }
    
    // 使用fmod函数计算value相对于周期的余数
    // fmod返回value除以period的余数，符号与value相同
    double result = fmod(value, period);
    
    // 如果余数为负数，需要加上周期使其落在[0, period)范围内
    if (result < 0.0) {
        result += period;
    }
    
    // 返回归一化后的结果，确保在[0, period)范围内
    return result;
}


/*******************************************************************************
 函数名称：lm_period_normalize_symmetric
 功能描述：将浮点数归一化到指定周期范围内[-period/2, +period/2)
 输入参数：value  - 待归一化的浮点数
          period - 周期长度（必须为正数）
 输出参数：无    
 返 回 值：归一化后的浮点数，范围在[-period/2, +period/2)内
 其它说明：通过取模运算将任意浮点数映射到指定周期范围内		   
 			   
 修改日期      版本号          修改人            修改内容
 -----------------------------------------------------------------------------
 2025/11/02     V1.00          Qiguo_Cui          创建
 *******************************************************************************/  
double lm_period_normalize_symmetric(double value, double period) {
    double normalized = lm_period_normalize(value, period);
    if (normalized >= period/2) {
        normalized -= period;
    }
    return normalized;
}


/*******************************************************************************
 函数名称：lm_angle_normalize_0_to_2pi
 功能描述：将任意角度值归一化到[0, 2π)弧度范围内    
 输入参数：angle_rad - 待归一化的角度值（单位：弧度）
 输出参数：无    
 返 回 值：归一化后的角度值，范围在[0, 2π)弧度内
 其它说明：通过模运算将任意角度映射到完整的圆周范围		   
 			   
 修改日期      版本号          修改人            修改内容
 -----------------------------------------------------------------------------
 2025/11/02     V1.00          Qiguo_Cui          创建
 *******************************************************************************/  
double lm_angle_normalize_0_to_2pi(double angle_rad) {
    
    // 定义π常量，用于角度计算
    const double PI = 3.14159265358979323846;
    const double TWO_PI = 2.0 * PI;
    
    // 使用fmod函数计算角度相对于2π的余数
    // fmod返回angle_rad除以2π的余数，符号与angle_rad相同
    double normalized = fmod(angle_rad, TWO_PI);
    
    // 如果余数为负数，需要加上2π使其落在[0, 2π)范围内
    if (normalized < 0.0) {
        normalized += TWO_PI;
    }
    
    // 特殊情况处理：当角度非常接近2π时，确保不会返回2π
    // 由于浮点数精度问题，可能需要额外检查
    if (normalized >= TWO_PI) {
        normalized = 0.0;
    }
    
    // 返回归一化到[0, 2π)范围内的角度值
    return normalized;
}

/*******************************************************************************
 函数名称：lm_angle_normalize_neg_pi_to_pi
 功能描述：将任意角度值归一化到[-π, π)弧度范围内    
 输入参数：angle_rad - 待归一化的角度值（单位：弧度）
 输出参数：无    
 返 回 值：归一化后的角度值，范围在[-π, π)弧度内
 其它说明：通过模运算将任意角度映射到对称的圆周范围，保持方向信息		   
 			   
 修改日期      版本号          修改人            修改内容
 -----------------------------------------------------------------------------
 2025/11/02     V1.00          Qiguo_Cui          创建
 *******************************************************************************/  
double lm_angle_normalize_neg_pi_to_pi(double angle_rad) {
    
    // 定义π常量，用于角度计算
    const double PI = 3.14159265358979323846;
    const double TWO_PI = 2.0 * PI;
    
    // 使用fmod函数计算角度相对于2π的余数
    double normalized = fmod(angle_rad, TWO_PI);
    
    // 调整到[-2π, 2π)范围内后，进一步调整到[-π, π)范围内
    if (normalized > PI) {
        normalized -= TWO_PI;
    } else if (normalized < -PI) {
        normalized += TWO_PI;
    }
    
    // 特殊情况处理：当角度非常接近π时，确保不会返回π
    // 由于浮点数精度问题，可能需要额外检查
    if (normalized >= PI) {
        normalized = -PI;
    }
    
    // 返回归一化到[-π, π)范围内的角度值
    return normalized;
}

/*******************************************************************************
 函数名称： linear_interpolation
 功能描述： 在两个已知数据点之间进行线性插值计算，根据已知两点坐标计算目标x坐标对应的y值    
 输入参数： x0 - 第一个已知点的x坐标，双精度浮点数
           y0 - 第一个已知点的y坐标，双精度浮点数  
           x1 - 第二个已知点的x坐标，双精度浮点数
           y1 - 第二个已知点的y坐标，双精度浮点数
           x  - 需要插值计算的x坐标，双精度浮点数
 输出参数： 无
 返 回 值： 插值计算得到的y坐标值，双精度浮点数。如果输入参数不合法，返回0
 其它说明： 使用线性插值公式：y = y0 + (y1 - y0) * (x - x0) / (x1 - x0)
           当x0等于x1时会返回错误信息并返回0值
			   
 修改日期      版本号          修改人            修改内容
 -----------------------------------------------------------------------------
 2025/10/21     V1.00          Qiguo_Cui          创建
 *******************************************************************************/
double lm_linear_interpolation(double x0,  /* 第一个已知点的x坐标 */
                           double y0,  /* 第一个已知点的y坐标 */
                           double x1,  /* 第二个已知点的x坐标 */
                           double y1,  /* 第二个已知点的y坐标 */
                           double x)   /* 需要插值计算的x坐标 */
{
    // 检查x0和x1是否相同，避免除以零的错误情况
    if (x0 == x1) 
    {
        // 输出错误提示信息到控制台
        printf("错误：x0 和 x1 不能相同\n");
        // 返回0值表示计算失败
        return 0;
    }
    
    // 计算插值结果：使用线性插值公式进行计算
    // 公式：y = y0 + (y1 - y0) * (x - x0) / (x1 - x0)
    double result = y0 + (y1 - y0) * (x - x0) / (x1 - x0);
    
    // 返回计算得到的插值结果
    return result;
}

/*******************************************************************************
 函数名称： clamp
 功能描述： 将输入数值限制在指定的最小值和最大值范围内    
 输入参数： value - 需要被限制的原始数值，双精度浮点数
           min_value - 允许的最小值，双精度浮点数
           max_value - 允许的最大值，双精度浮点数
 输出参数： 无
 返 回 值： 限制在[min_value, max_value]范围内的数值，双精度浮点数
 其它说明： 如果min_value > max_value，函数会自动交换最小值和最大值
           确保返回值始终在有效的范围内
			   
 修改日期      版本号          修改人            修改内容
 -----------------------------------------------------------------------------
 2025/10/21     V1.00          Qiguo_Cui          创建
 *******************************************************************************/
double lm_clamp(double value,      /* 需要被限制的原始数值 */
             double min_value,  /* 允许的最小值 */
             double max_value)  /* 允许的最大值 */
{
    // 局部变量声明，用于存储处理后的最小值和最大值
    double actual_min, actual_max;
    
    // 检查并确保最小值不大于最大值，如果不符合则自动交换
    if (min_value <= max_value) 
    {
        // 当最小值小于等于最大值时，直接使用输入的最小最大值
        actual_min = min_value;
        actual_max = max_value;
    }
    else
    {
        // 当最小值大于最大值时，交换两者以确保范围有效
        actual_min = max_value;
        actual_max = min_value;
    }
    
    // 如果输入值小于实际最小值，则返回最小值
    if (value < actual_min) 
    {
        return actual_min;
    }
    // 如果输入值大于实际最大值，则返回最大值
    else if (value > actual_max) 
    {
        return actual_max;
    }
    // 如果输入值在范围内，则直接返回原值
    else 
    {
        return value;
    }
}